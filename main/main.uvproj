# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\delay;..\ds18b20;..\lcd12864;..\ds1302
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../delay/: delay.c
    ../ds18b20/: ds18b20.c
    ../lcd12864/: lcd12864.c
    ../ds1302/: ds1302.c
